# Keil uVision project PID_SPEED.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PID_SPEED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c fonts.c fonts.h my_clock.c my_clock.h my_dma.c my_dma.h my_encoder.c my_encoder.h my_gpio.c my_gpio.h my_pid.c my_pid.h my_spi.c my_spi.h my_systick.c my_systick.h my_timer.c my_timer.h st7735.c st7735.h remote.c remote.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
